<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F070CBT6_QUADROTOR_CONTROLLER.ewp</path>
  </project>
  <batchBuild />
</workspace>
